# Keil uVision project stm32_ppm_usb_converter.uvprojx, settings and files
target stm32f103c8 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32_ppm_usb_converter
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STM3210B_EVAL
  c include: ./core/include/;./core/include/usb;./lib/STM32_USB-FS-Device_Driver/inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ./core/src/: main.c retarget.c ppm_decoder.c ppm_reader.c
  group rx
    ./core/src/rx/: drv_spi.c drv_time.c drv_xn297.c led.c rx_nrf24_bayang_telemetry.c
  group usb
    ./core/src/usb/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c stm32_it.c
    ./core/include/usb/: usb_conf.h platform_config.h
  group STM32_USB-FS-Device_Driver
    ./lib/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
software components: CMSIS:CORE 5.2.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
